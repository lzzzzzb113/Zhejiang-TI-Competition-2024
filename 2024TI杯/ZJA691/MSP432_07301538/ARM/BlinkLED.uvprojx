# Keil uVision project BlinkLED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlinkLED
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User\LCD;..\ti\devices\msp432e4\driverlib;..\User\Key;..\User\ADC;..\fft\inc;..\User\DSP_Nuedc;..\..\MSP432_07300940;..\User;..\..\..\MSP432_07301538
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group main
    ../: main.c uartstdio.c uartstdio.h
    ../User/ADC/: bsp_ADC.c
    ../User/DSP_Nuedc/: SignalProcess.c
  group lib
    ../ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
  group lcd
    ../User/LCD/: Key.c LCD1602.c
  group fft
    ../fft/src/: fft.c
software components: CMSIS:CORE 5.5.0, Device:Startup 3.2.3
